
#include "Movies.h"
#include "ext_common.h"
#include "ext.h"
#include "ext_user.h"
#include "n2.basicstrings.c"
#include "n2.0000.h"
#include "agl.h"
#include "GL/glut.h" //glu glu++



typedef struct zttz 
{
	Object    n_ob;
 	void     *n2hdr;    // required nato - position = important _ must b 2nd
	
    void   	 *glout;
    short     type;
    GLfloat   vertex,vertex2,red,green,blue,
              normalx,normaly,normalz;  
    GLboolean texture;              
    long      shademodel;

    Boolean        on;  
    
    	long               v1, v2, divx, divy, plus, fuzzymin, fuzzymax, depth, dx;
	short		 mode, variant, rows, columns, red, green, blue;
	double 		ra, rb;


} NNato;


void *nnato_new(void);
void nnato_assist(NNato *x, void *b, long msg, long nr, char *s);
void nnato_info(NNato *x, void *p, void *b);

void nnato_free(NNato *x);
void nnato_on(NNato *x, long flag);
void nnato_bang(NNato *x);
void nnato_int(NNato *x, long n);   
void nnato_variant(NNato *x, short variant);

void nnato_type(NNato *x, short type);
void nnato_vertex(NNato *x, long vertex, long vertex2);
void nnato_shademodel(NNato *x, long type);
void nnato_klr(NNato *x, long red, long green, long blue);
void nnato_normalz(NNato *x, long koordx, long koordy, long koordz);
void nnato_texture(NNato *x, long flag);
void nnato_revertgeo(NNato *x);
void nnato_revert(NNato *x);

void nnato_mode(NNato *x,   short mode);
void nnato_v1(NNato *x,long v1);
void nnato_v2(NNato *x,  long v2);
void nnato_ra(NNato *x, double ra);
void nnato_rb(NNato *x, double rb);
void nnato_plus(NNato *x, long plus);
void nnato_divx(NNato *x, long val);
void nnato_divy(NNato *x, long val);
void nnato_div(NNato *x, long val);

void nnato_fuzzy(NNato *x,long val, long val2);
void nnato_depth(NNato *x,long val);
void nnato_reset(NNato *x);

void nnato_variant(NNato *x, short variant);
double map_alpha(NNato *x);
double map_beta(double low, double high, double a, double b, double mu, double sigsqr) ;
double beta_value(double a, double b);
double non_zero_random(void);
double ran(void);
double alea(double min, double max);
double mapvalue(double x, double a, double b, double c, double d);

void nnato_rows(NNato *x, short rows);
void nnato_columns(NNato *x, short columns);
void nnato_red(NNato *x, short red);
void nnato_green(NNato *x, short green);
void nnato_blue(NNato *x, short blue);



void nnato_glfun(n2glatom glatom);
void nnato_glregister(NNato *x, void *klientz);



void    *nnato_class;

main()
{
	setup(&nnato_class, nnato_new, (method)nnato_free, (short)sizeof(NNato), 0L, 0L, 0);

 	addmess((method)nnato_assist,	                  "assist",          	A_CANT,0);
 	addmess((method)nnato_info,	                      "info",		        A_CANT,0);

    n2objaddglcmd();
    n2addstatecmd((method)nnato_int,(method)nnato_bang,
                  (method)nnato_on,-1,-1,-1,-1,(method)nnato_variant,0);

    addmess((method)nnato_type,                       "drau.type",          A_DEFLONG,0);
    addmess((method)nnato_shademodel,                 "normal.type",        A_DEFLONG,0);
    addmess((method)nnato_normalz,                    "normal",             A_DEFLONG,A_DEFLONG,A_DEFLONG,0);
    addmess((method)nnato_klr,                        "color",              A_DEFLONG,A_DEFLONG,A_DEFLONG,0);
    addmess((method)nnato_texture,                    "texture",            A_DEFLONG,0);
    addmess((method)nnato_vertex,                     "geo",                A_DEFLONG,A_DEFLONG,0);
    addmess((method)nnato_revertgeo,                  "revert.geo",         0);
    addmess((method)nnato_revert,                     "revert",             0);

    n2reklama();
    n2addfklass("242.glrekt");	
}





void nnato_assist(NNato *x, void *b, long msg, long nr, char *s)
{
	if (msg == 1)      // !nlet
	   strcpy( s, m9ndfukcpropaganda00);
       {
	   if (msg == 2)   // outlet
	      if (nr == 0)
	         strcpy( s, n2gltypestr);  // default `gl data type` outlet de[a]ss!zt--
	   }
}


void nnato_info(NNato *x, void *p, void *b)
{ 
     n2info();
}


void *nnato_new()
{
    NNato      *x;
	short      err;

	x = (NNato *)newobject(nnato_class);
    n2addoutlet(x,&x->glout);    

    if (err = n2objinit(x))
       { post("242.glrekt :  n2initobjekt err = %ld",err); return;} 

    n2objsetglregister(x,(method)nnato_glregister);   // zpecify gl regizter routine
    n2objsetglfun(x,(method)nnato_glfun);             // zpecify gl drau routine

    nnato_revert(x);
		
	x->on = true;
	return (x);
   
ikk:
	nnato_free(x);
}



void nnato_free(NNato *x)
{   
    n2objfree(x);
}



void nnato_on(NNato *x, long flag)
{    
    x->on = flag;
}  


void nnato_int(NNato *x, long n)    
{								    
   if (!n) x->on = false;
   else x->on = true;
}


void nnato_bang(NNato *x)
{
   n2gldraw(x, n2objtype);
}


void nnato_variant(NNato *x, short variant)
{
   // e.g. if (!variant) n2objsetglfun(x,(method)nnato_glfun); etc
}


void nnato_type(NNato *x, short type)
{
   if (type >= 0 && type <= 9) x->type = type;
}


void nnato_klr(NNato *x, long red, long green, long blue)
{
   x->red   = (float)red   * 0.01;
   x->green = (float)green * 0.01;
   x->blue  = (float)blue  * 0.01;      
}  

void nnato_normalz(NNato *x, long koordx, long koordy, long koordz)
{
   x->normalx  = (float)koordx * 0.01;
   x->normaly  = (float)koordy * 0.01;
   x->normalz  = (float)koordz * 0.01;      
}  


void nnato_shademodel(NNato *x, long type)
{
   if (type == 0) x->shademodel = GLU_SMOOTH;
   else if (type == 1) x->shademodel = GLU_FLAT;
   else if (type == 2) x->shademodel = GLU_NONE;
}

void nnato_vertex(NNato *x, long vertex, long vertex2)
{
    x->vertex   = (float)vertex  * .01;
    x->vertex2  = (float)vertex2 * .01;
}			


void nnato_texture(NNato *x, long flag)
{
    x->texture = flag;
}

void nnato_revertgeo(NNato *x)
{	
    x->vertex = x->vertex2 = .5;   
}		

void nnato_revert(NNato *x)
{	
	x->type = 6;	
    x->vertex = x->vertex2 = .5;
    x->shademodel = GLU_SMOOTH;
 
    x->normalx = x->normaly = 0.0;
    x->normalz = 1.0;
    
    x->texture = true;
    nnato_klr(x,50,50,50);
}


#pragma mark - xxmethods		//

void nnato_mode(NNato *x,   short mode)
{
   x->mode = mode;
}

void nnato_v1(NNato *x, long v1)
{
   x->v1 = v1;
}

void nnato_v2(NNato *x, long v2)
{
   x->v2 = v2;
}

void nnato_ra(NNato *x, double ra)
{
   x->ra  = ra;
}

void nnato_rb(NNato *x, double rb)
{
   x->rb = rb;
}

void nnato_plus(NNato *x, long plus)
{
   x->plus = plus;
}

void nnato_divx(NNato *x, long val)
{
        x->divx=val;
}

void nnato_divy(NNato *x, long val)
{
        x->divy=val;
}

void nnato_div(NNato *x, long val)
{
        x->divx=x->divy = val;
}

void nnato_fuzzy(NNato *x, long val, long val2)
{
        x->fuzzymin= val;
        x->fuzzymax= val2;        
}

void nnato_depth(NNato *x, long val)
{
        x->depth= val;
}



double map_alpha(NNato *x)
{
	double a , b;
	a=x->ra; b=x->rb;
	return (  alea(a, b)  );
}

double map_beta(double low, double high, double a, double b, double mu, double sigsqr) 			//			ŒcŒv  paul.d  randbeta.c
{
	return(mapvalue(beta_value(a, b), mu, sigsqr,low, high));
}

// 
// beta distribution algorithm derived from Dodge's FORTRAN example, some of 
// the same variable names are used a and b should be doubles 0-1 
// value returned between 0 and 1 
//
double beta_value(double a, double b)
{
	
	double y1, y2, sum, ainv, binv;
	
	ainv = 1.0/a;
	binv = 1.0/b;

	do 
	{
	 	y1 = pow(non_zero_random(), ainv);
	 	y2 = pow(non_zero_random(), binv);
	 	sum = y1+y2;
	}
	while(sum  > 1.0);
	
	return(y1 / sum);
}

// 
// returns a non-zero random number between 0 and 1 
// 
double non_zero_random(void)
{
	double value;
	do 
	{
		value = ran();
	}	   
	while (value == 0.0);
	
	return(value);
}

// 
// returns a random double between 0 and 1 
//
double ran(void)
{	
	return(alea(0.0, 1.0));
}

//
// returns a random value as double between min and max value 
// ANSI says that RAND_MAX = 32767, pretty piss poor I say!
//
double alea(double min, double max)
{
	if (max >= min)
		return ((max-min)*((double)rand()/RAND_MAX) + min);
	else
		return ((min-max)*((double)rand()/RAND_MAX) + max);
	
}

//
// maps x in the range a-b to the range c-d  returns a double 
//	
double mapvalue (double x, double a, double b, double c, double d) 
{	
	return((x - a) * (d-c)/(b-a) + c);
}


void nnato_red(NNato *x, short red)
{
   x->red = red;
}
void nnato_green(NNato *x, short green)
{
   x->green = green;
}
void nnato_blue(NNato *x, short blue)
{
   x->blue = blue;
}

void nnato_rows(NNato *x, short rows)
{
	if (rows<1) rows=1;
	if (rows>240) rows=240;
	x->rows = rows;
}

void nnato_columns(NNato *x, short columns)
{
	if (columns<1) columns=1;
	if (columns>320) columns=320;
	x->columns = columns;   
}


#pragma mark - fun		//













void nnato_glfun(n2glatom glatom)
{
    NNato *x = (NNato *)n2getglatomobj(glatom);
    float  a  = x->vertex,
           b  = x->vertex2;                        
   
    if (!x->on) return;
    
    glShadeModel(x->shademodel);
    glColor3f(x->red, x->green, x->blue);
 
    
 	glBegin(x->type);
 	glNormal3f(x->normalx,x->normaly,x->normalz);
 	
 	if (x->texture)
 	   {
	        glTexCoord2f(0.0f, 0.0f);
                glVertex3f(-a, -b, 0.0f);
	        glTexCoord2f(1.0f, 0.0f);
                glVertex3f( a, -b, 0.0f);
	        glTexCoord2f(1.0f, 1.0f);
                glVertex3f( a, b, 0.0f);
	        glTexCoord2f(0.0f, 1.0f);
                glVertex3f(-a, b, 0.0f);
 	   }
 	else
 	   {
                glVertex3f(-a, -b, 0.0f);
                glVertex3f( a, -b, 0.0f);
                glVertex3f( a, b, 0.0f);
                glVertex3f(-a, b, 0.0f);
              
       }
	glEnd();
} 



void nnato_glregister(NNato *x, void *klientz)
{
    n2glregisterx(x,n2objtype,x->glout,klientz);  // bkom 01 klient ov gl alimentari data
}			






