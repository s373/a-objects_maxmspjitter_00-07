
#include "Movies.h"
#include "ext_common.h"
#include "ext.h"
#include "ext_user.h"
#include "n2.basicstrings.c"
#include "n2.0000.h"
#include "agl.h"
#include "GL/glut.h" //glu glu++



typedef struct zttz 
{
	Object    n_ob;
 	void     *n2hdr;    // required nato - position = important _ must b 2nd
	
    void   	 *glout;

    Boolean        on;  

} NNato;


void *nnato_new(void);
void nnato_assist(NNato *x, void *b, long msg, long nr, char *s);
void nnato_info(NNato *x, void *p, void *b);

void nnato_free(NNato *x);
void nnato_on(NNato *x, long flag);
void nnato_bang(NNato *x);
void nnato_int(NNato *x, long n);   
void nnato_variant(NNato *x, short variant);


void nnato_glfun(n2glatom glatom);
void nnato_glregister(NNato *x, void *klientz);



void    *nnato_class;

main()
{
	setup(&nnato_class, nnato_new, (method)nnato_free, (short)sizeof(NNato), 0L, 0L, 0);

 	addmess((method)nnato_assist,	                  "assist",          	A_CANT,0);
 	addmess((method)nnato_info,	                      "info",		        A_CANT,0);

    n2objaddglcmd();
    n2addstatecmd((method)nnato_int,(method)nnato_bang,
                  (method)nnato_on,-1,-1,-1,-1,(method)nnato_variant,0);

    n2reklama();
    n2addfklass("242.glaxis");	
}





void nnato_assist(NNato *x, void *b, long msg, long nr, char *s)
{
	if (msg == 1)      // !nlet
	   strcpy( s, m9ndfukcpropaganda00);
       {
	   if (msg == 2)   // outlet
	      if (nr == 0)
	         strcpy( s, n2gltypestr);  // default `gl data type` outlet de[a]ss!zt--
	   }
}


void nnato_info(NNato *x, void *p, void *b)
{ 
     n2info();
}


void *nnato_new()
{
    NNato      *x;
	short      err;

	x = (NNato *)newobject(nnato_class);
    n2addoutlet(x,&x->glout);    

    if (err = n2objinit(x))
       { post("242.glaxis :  n2initobjekt err = %ld",err); return;} 

    n2objsetglregister(x,(method)nnato_glregister);   // zpecify gl regizter routine
    n2objsetglfun(x,(method)nnato_glfun);             // zpecify gl drau routine

		
	x->on = true;
	return (x);
   
ikk:
	nnato_free(x);
}



void nnato_free(NNato *x)
{   
    n2objfree(x);
}



void nnato_on(NNato *x, long flag)
{    
    x->on = flag;
}  


void nnato_int(NNato *x, long n)    
{								    
   if (!n) x->on = false;
   else x->on = true;
}


void nnato_bang(NNato *x)
{
   n2gldraw(x, n2objtype);
}


void nnato_variant(NNato *x, short variant)
{
   // e.g. if (!variant) n2objsetglfun(x,(method)nnato_glfun); etc
}






void nnato_glfun(n2glatom glatom)
{
    NNato *x = (NNato *)n2getglatomobj(glatom);
   
    if (!x->on) return;
    
		   glBegin(GL_LINES);

		   glColor4f(0.5,0.5,0.0,1.0);  // Mid-level yellow.

		   // Three primary axis lines.
		   glVertex3f(100,0,0);
		   glVertex3f(-100,0,0);
		   glVertex3f(0,100,0);
		   glVertex3f(0,-100,0);
		   glVertex3f(0,0,100);
		   glVertex3f(0,0,-100);

		   glColor4f(0.25,0.25,0.0,1.0);  // Low-level yellow.

		   // Two pairs of secondary lines for X and Z axis.
		   glVertex3f(100,1,0);
		   glVertex3f(-100,1,0);
		   glVertex3f(100,-1,0);
		   glVertex3f(-100,-1,0);

		   glVertex3f(0,1,100);
		   glVertex3f(0,1,-100);
		   glVertex3f(0,-1,100);
		   glVertex3f(0,-1,-100);

		   glColor4f(0.0,0.5,0.0,1.0); // Mid-level green.

		   // Lable the X axis.
		   glVertex3f(1.0,0.9,0);
		   glVertex3f(1.1,0.8,0);
		   glVertex3f(1.1,0.9,0);
		   glVertex3f(1.0,0.8,0);

		   // And the Z.
		   glVertex3f(0,0.9,1.0);
		   glVertex3f(0,0.9,1.1);
		   glVertex3f(0,0.9,1.1);
		   glVertex3f(0,0.8,1.0);
		   glVertex3f(0,0.8,1.0);
		   glVertex3f(0,0.8,1.1);

		   
		
              
       
	glEnd();
}



void nnato_glregister(NNato *x, void *klientz)
{
    n2glregisterx(x,n2objtype,x->glout,klientz);  // bkom 01 klient ov gl alimentari data
}			






