																								/*


					242.1/f _ sier
					
									    1/f image distortion



*/
#include "Movies.h"
#include "ext_common.h"
#include "ext.h"
#include "ext_user.h"
//#include "stdlib.h"
#include "math.h"		//  here ?
#include "n2.basicstrings.c"
#include "n2.0000.h"     // n2.inkludes



typedef struct zttz 
{
	Object   n_ob;     // required max
 	void     *n2hdr;   // required nato - position = signifikant _ must b 2nd
	void             *dataout;      // n2data outlet
	n2imgptr         gvelt;         // img buffer

	short 			seed, length;    //variaveis



    Boolean          on,bypass,freeze,think,quarrel;  // nato.objstate flagz

} NNato;



void *nnato_new(short seed, short length);
void nnato_assist(NNato *x, void *b, long msg, long nr, char *s);
void nnato_info(NNato *x, void *p, void *b);
void nnato_free(NNato *x);
void nnato_processimage(NNato *x, n2atom *data);
void nnato_processimage2(NNato *x, n2atom *data);
void nnato_processimage3(NNato *x, n2atom *data);


void nnato_on(NNato *x, long flag);
void nnato_bypass(NNato *x, long flag);
void nnato_freeze(NNato *x, long flag);
void nnato_int(NNato *x, long n);
void nnato_bang(NNato *x);
void nnato_think(NNato *x, short val);
void nnato_quarrel(NNato *x, short val);
void nnato_variant(NNato *x, short variant);

float frand (NNato *x);
void nnato_length		(NNato *x, short length);
void nnato_seed		(NNato *x, short n);

void     *nnato_class;



main(void)
{
	setup(&nnato_class, nnato_new, (method)nnato_free, (short)sizeof(NNato), 0L, 
	      A_DEFLONG,A_DEFLONG, 0);

    n2objaddimagecmd();
    n2addstatecmd((method)nnato_int,(method)nnato_bang,
                  (method)nnato_on,(method)nnato_freeze,(method)nnato_bypass,
                  (method)nnato_think,(method)nnato_quarrel,(method)nnato_variant,0);

 	addmess((method)nnato_assist,	                   "assist",    	A_CANT,0);
 	addmess((method)nnato_info,	                       "info",		    A_CANT,0);

	addmess((method)nnato_length,					"length",			A_DEFLONG,0);
	addmess((method)nnato_seed,							"seed",			A_DEFLONG,0);
	

 
 //   n2reklama();
    n2addfklass("242.1/f");

    post("");
    post("glu glu++");
    post("											*");
//    post("");
  //  post("");
  //  post("");
 //   post("");

}




void nnato_assist(NNato *x, void *b, long msg, long nr, char *s)
{
	if (msg == 1)      // !nlet
	   sprintf( s, "]]] \\in.%ld",x->seed);     // s!ng.oun.pra!zez - comment +? hap!l+e +? da. 
    else
       {
	   if (msg == 2)   // outlet
	      if (nr == 0)
	   sprintf( s, "]]] \\out.%ld",(x->seed&999));  // default `image data type` outlet de[a]ss!zt--
       }
}


void nnato_info(NNato *x, void *p, void *b)
{ 
     n2info();
}



void *nnato_new(short seed, short length)
{
	NNato      *x;
    short      err;
  	
	x = (NNato *)newobject(nnato_class);
    n2addoutlet(x,&x->dataout);    

    if (err = n2objinit(x))
       { post("242.1/f  :  n2objinit err = %ld",err); return;} 
       
    if ((err = n2inewimage(&x->gvelt,n2idefwidth,n2idefheight)))
       { post("242.1/f  :  n2inewimage err = %ld",err); goto ikk;}  

    n2objsetimagefun(x,(method)nnato_processimage);

    x->seed=0;
    x->length=100;   
    
	x->on = true;
    x->bypass = x->freeze = x->think = x->quarrel = false;     
  
    return (x);

ikk:
	nnato_free(x);
}


void nnato_free(NNato *x)
{
    if (x->gvelt) { n2idisposeimage(x->gvelt); x->gvelt = 0;}
    n2objfree(x);
}


void nnato_on(NNato *x, long flag)
{    
    x->on = flag;
}  
 
 
void nnato_bypass(NNato *x, long flag)
{    
    x->bypass = flag;
}  
 
   
void nnato_freeze(NNato *x, long flag)
{    
    x->freeze = flag;
} 

void nnato_int(NNato *x, long n)
{
   n2defintstatefun(x,n);
}


void nnato_bang(NNato *x)
{
   n2registerimage(x,n2objtype,x->dataout,0,x->gvelt);
}

void nnato_think(NNato *x, short val)
{
   x->think = val;
}

void nnato_quarrel(NNato *x, short val)
{
   x->quarrel = val;
}

void nnato_variant(NNato *x, short variant)
{
   if (!variant)
       n2objsetimagefun(x,(method)nnato_processimage); 
   else if (variant == 1)
       n2objsetimagefun(x,(method)nnato_processimage2);
   else if (variant == 2)
       n2objsetimagefun(x,(method)nnato_processimage3);
}






void nnato_seed		(NNato *x, short n)
{
x->seed = n;
}


void nnato_length		(NNato *x, short length)
{
x->length = length;
}


float frand(NNato *x)
{
	unsigned long n;
	
	x->seed = x->seed * 1103515245 + 12345;
	n = x->seed & 2147483647;
	return(((float)n)/2147483648.0);
}




void nnato_processimage(NNato *x, n2atom *data)
{                   
    long           i, j, roubitez, pix;                          
    short          width, height, err;  
    
    float summ, rg[16], nr;
	short k, kg, sum;
	long ng, threshold, np, nbits;              
                  
                             
    Ptr            src, dst, srcadresz, dstadresz;      
    n2pixmaphdl    srcpixmap, dstpixmap;
    n2pixstate     srcpixztate, dstpixztate;
    n2imgptr       dstgvelt, gveltptr = n2getatomimage(data);


        if (!x->on || !gveltptr) return;

        if (x->freeze)
           {   
              n2registerimage(x,n2objtype,x->dataout,data,x->gvelt);
              return;
           }
               
        if (x->bypass)
           {
              n2registerimage(x,n2objtype,x->dataout,data,gveltptr);
              return;   
           } 

        if ((err = n2iensuredimeq(&gveltptr,&x->gvelt)))
           {
             post ("242.1/f  : n2iensureimagedimeq err = %ld", err);
             return;
           }  
 
        if (!x->think)          
            srcpixmap   = n2igetpixmap(gveltptr);
        else
            srcpixmap   = n2igetpixmap(x->gvelt);
       
        if (!x->quarrel) 
            dstgvelt = x->gvelt;
        else
            dstgvelt = gveltptr;
                 
        dstpixmap   = n2igetpixmap(dstgvelt);
 
        srcpixztate = n2igetpixstate(srcpixmap);        
        dstpixztate = n2igetpixstate(dstpixmap);        
        if (!n2ilockpix(srcpixmap)) return;       
        if (!n2ilockpix(dstpixmap)) goto ikk;
              
        srcadresz = n2igetpixaddr(srcpixmap);
        dstadresz = n2igetpixaddr(dstpixmap);
		roubitez  = n2igetpixrowbytes(srcpixmap); 

        n2igetdim(gveltptr,&width,&height);


	nbits = 1;
	np = 1;
	nr = (float)x->length;
	nr = nr/2;
	while (nr>1)
	{
		nbits++;
		np=2*np;
		nr=nr/2;
	}
	for (kg=0; kg<nbits; kg++)
		rg[kg] = frand(x);
	for (k=0; k<x->length; k++)
	{
		threshold = np;
		ng = nbits;
		while (k%threshold != 0)
		{
			ng--;
			threshold=threshold/2;
		}
		summ=0;
		for (kg=0; kg<nbits; kg++)
		{
			if (kg<ng)
				rg[kg] = frand(x);
			summ+=rg[kg];
		}
		
	}

            
        for(i = 0; i < height; i++) 
         {
            src = srcadresz + i * roubitez;            
            dst = dstadresz + i * roubitez;
//            rgg = frand(x);       
            for(j = 0; j < width; j++)
            {
                pix = n2get32(src);
                        
				n2set32m(dst,
				         n2get32alpha(pix),
				         n2klamp255(n2get32red(pix)   + (long)summ),
				         n2klamp255(n2get32green(pix) + (long)summ),
				         n2klamp255(n2get32blue(pix)  + (long)summ));

				src+=4;
				dst+=4;					
             }
		 }
  
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);

        n2registerimage(x,n2objtype,x->dataout,data,dstgvelt);
        return;
        
ikk: 
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);
}		




void nnato_processimage2(NNato *x, n2atom *data)

{                   
    long           i, j, roubitez, pix;                          
    short          width, height, err;  
    
    float sum, rg[16], nr;
	short k, kg;
	long ng, threshold, np, nbits;              
                  
                             
    Ptr            src, dst, srcadresz, dstadresz;      
    n2pixmaphdl    srcpixmap, dstpixmap;
    n2pixstate     srcpixztate, dstpixztate;
    n2imgptr       dstgvelt, gveltptr = n2getatomimage(data);


        if (!x->on || !gveltptr) return;

        if (x->freeze)
           {   
              n2registerimage(x,n2objtype,x->dataout,data,x->gvelt);
              return;
           }
               
        if (x->bypass)
           {
              n2registerimage(x,n2objtype,x->dataout,data,gveltptr);
              return;   
           } 

        if ((err = n2iensuredimeq(&gveltptr,&x->gvelt)))
           {
             post ("242.1/f  : n2iensureimagedimeq err = %ld", err);
             return;
           }  
 
        if (!x->think)          
            srcpixmap   = n2igetpixmap(gveltptr);
        else
            srcpixmap   = n2igetpixmap(x->gvelt);
       
        if (!x->quarrel) 
            dstgvelt = x->gvelt;
        else
            dstgvelt = gveltptr;
                 
        dstpixmap   = n2igetpixmap(dstgvelt);
 
        srcpixztate = n2igetpixstate(srcpixmap);        
        dstpixztate = n2igetpixstate(dstpixmap);        
        if (!n2ilockpix(srcpixmap)) return;       
        if (!n2ilockpix(dstpixmap)) goto ikk;
              
        srcadresz = n2igetpixaddr(srcpixmap);
        dstadresz = n2igetpixaddr(dstpixmap);
		roubitez  = n2igetpixrowbytes(srcpixmap); 

        n2igetdim(gveltptr,&width,&height);


	nbits = 1;
	np = 1;
	nr = (float)x->length;
	nr = nr/2;
	while (nr>1)
	{
		nbits++;
		np=2*np;
		nr=nr/2;
	}
	for (kg=0; kg<nbits; kg++)
		rg[kg] = frand(x);
	for (k=0; k<x->length; k++)
	{
		threshold = np;
		ng = nbits;
		while (k%threshold != 0)
		{
			ng--;
			threshold=threshold/2;
		}
		sum=0;
		for (kg=0; kg<nbits; kg++)
		{
			if (kg<ng)
				rg[kg] = frand(x);
			sum+=rg[kg];
		}
		
	}

            
        for(i = 0; i < height; i++) 
         {
            src = srcadresz + i * roubitez;            
            dst = dstadresz + i * roubitez;
                      
            for(j = 0; j < width; j++)
            {
                pix = n2get32(src);
                        
				n2set32m(dst,
				         n2get32alpha(pix),
				         n2klamp255(n2get32red(pix)   + (long)sum),
				         n2klamp255(n2get32green(pix) + (long)sum),
				         n2klamp255(n2get32blue(pix)  + (long)sum));

				src+=4;
				dst+=4;					
             }
		 }
  
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);

        n2registerimage(x,n2objtype,x->dataout,data,dstgvelt);
        return;
        
ikk: 
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);
}		







void nnato_processimage3(NNato *x, n2atom *data)   
{                   
    long           i, j, roubitez, pix;                          
    short          width, height, err;  
    
    float sum, rg[16], nr;
	short k, kg;
	long ng, threshold, np, nbits;              
                  
                             
    Ptr            src, dst, srcadresz, dstadresz;      
    n2pixmaphdl    srcpixmap, dstpixmap;
    n2pixstate     srcpixztate, dstpixztate;
    n2imgptr       dstgvelt, gveltptr = n2getatomimage(data);


        if (!x->on || !gveltptr) return;

        if (x->freeze)
           {   
              n2registerimage(x,n2objtype,x->dataout,data,x->gvelt);
              return;
           }
               
        if (x->bypass)
           {
              n2registerimage(x,n2objtype,x->dataout,data,gveltptr);
              return;   
           } 

        if ((err = n2iensuredimeq(&gveltptr,&x->gvelt)))
           {
             post ("242.1/f  : n2iensureimagedimeq err = %ld", err);
             return;
           }  
 
        if (!x->think)          
            srcpixmap   = n2igetpixmap(gveltptr);
        else
            srcpixmap   = n2igetpixmap(x->gvelt);
       
        if (!x->quarrel) 
            dstgvelt = x->gvelt;
        else
            dstgvelt = gveltptr;
                 
        dstpixmap   = n2igetpixmap(dstgvelt);
 
        srcpixztate = n2igetpixstate(srcpixmap);        
        dstpixztate = n2igetpixstate(dstpixmap);        
        if (!n2ilockpix(srcpixmap)) return;       
        if (!n2ilockpix(dstpixmap)) goto ikk;
              
        srcadresz = n2igetpixaddr(srcpixmap);
        dstadresz = n2igetpixaddr(dstpixmap);
		roubitez  = n2igetpixrowbytes(srcpixmap); 

        n2igetdim(gveltptr,&width,&height);


	nbits = 1;
	np = 1;
	nr = (float)x->length;
	nr = nr/2;
	while (nr>1)
	{
		nbits++;
		np=2*np;
		nr=nr/2;
	}
	for (kg=0; kg<nbits; kg++)
		rg[kg] = frand(x);
	for (k=0; k<x->length; k++)
	{
		threshold = np;
		ng = nbits;
		while (k%threshold != 0)
		{
			ng--;
			threshold=threshold/2;
		}
		sum=0;
		for (kg=0; kg<nbits; kg++)
		{
			if (kg<ng)
				rg[kg] = frand(x);
			sum+=rg[kg];
		}
		
	}

            
        for(i = 0; i < height; i++) 
         {
            src = srcadresz + i * roubitez;            
            dst = dstadresz + i * roubitez;
                      
            for(j = 0; j < width; j++)
            {
                pix = n2get32(src);
                        
				n2set32m(dst,
				         n2get32alpha(pix),
				         n2klamp255(n2get32red(pix)   + (long)sum),
				         n2klamp255(n2get32green(pix) + (long)sum),
				         n2klamp255(n2get32blue(pix)  + (long)sum));

				src+=4;
				dst+=4;					
             }
		 }
  
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);

        n2registerimage(x,n2objtype,x->dataout,data,dstgvelt);
        return;
        
ikk: 
	    n2isetpixstate(srcpixmap,srcpixztate);
        n2isetpixstate(dstpixmap,dstpixztate);
}		



