



/*
242.gltunnel.c

produzir sequencias de rects ao longo do eixo dos z's.

a struct deve ter distancia da origem para o lado e para cima
mais 3 valores para a rotacao/inclinacao do rectangulo.

*/

#include "Movies.h"
#include "ext.h"
#include "ext_common.h"
#include "ext_user.h"
#include "n2.basicstrings.c"
#include "n2.0000.h"
#include "agl.h"
#include "glut.h"
#include "math.h" //for sqrt

#define MAXLEN 256 //snake max vector points
#define MAXGRID 64 //gl max vector stuff


typedef struct
{	//floating
	float x;	//h dist
	float y;	//v dist
	float rotx,	//rot mags
		  roty,
		  rotz;
} Tunnel_atom;


typedef struct zttz 
{
	Object    n_ob;
 	void     *n2hdr;    // required nato - position = important _ must b 2nd
	
    void   	 *glout;	// out gl fun
    short     type, grid, step;//removed gridy and gridx->grid for vfun compatibility
    GLfloat   vertex,vertex2,red,green,blue,
              normalx,normaly,normalz, rate;
//    float     posit[MAXGRID][MAXGRID];  //globalize it
    GLboolean texture,border, calcFaceNorms, drawFaceNorms, antialias;              
    Boolean        on, doubl, ignt;  
	
	float		inputlist[MAXGRID];
	float		st;
//	short		listlenght, oplenght;
	 long      shademodel;

	 float		linewidth;
	 Boolean	lsmooth;

	float		rotx, roty, rotz, x, y;
	Tunnel_atom		tunnel[MAXLEN];
	short		tunCount, tunSize;

} NNato;

//global carve stuff
float	    posit[MAXGRID][MAXGRID];			        //position
float	    vertNorms[MAXGRID][MAXGRID][3];				//normals
float	    faceNorms[2][MAXGRID][MAXGRID][3];  		//facenormals
float	    faceNormSegs[2][2][MAXGRID][MAXGRID][3];	//facenormal segments
float 		texCoords[MAXGRID][MAXGRID][2];				//texture coordinates

//vector 
void copy(float vec0[3], float vec1[3]);
void sub(float vec0[3], float vec1[3], float vec2[3]);
void add(float vec0[3], float vec1[3], float vec2[3]);
void scalDiv(float vec[3], float c);
void cross(float vec0[3], float vec1[3], float vec2[3]);
void norm(float vec[3]);
void set(float vec[3], float x, float y, float z);

void getFaceNorms(NNato *x);
void getVertNorms(NNato *x);
void getFaceNormSegs(NNato *x);
void getTexCoords(NNato *x);
void drawFaceNormals(NNato *x);
void nnato_drawFaceNorms(NNato *x, long flag);

void nnato_calcFaceNorms(NNato *x, long flag);
void nnato_antialias(NNato *x, long flag);


void *nnato_new(void);
void nnato_assist(NNato *x, void *b, long msg, long nr, char *s);
void nnato_info(NNato *x, void *p, void *b);

void nnato_free(NNato *x);
void nnato_on(NNato *x, long flag);
void nnato_bang(NNato *x);
void nnato_int(NNato *x, long n);   
void nnato_variant(NNato *x, short variant);

void nnato_type(NNato *x, short type);
void nnato_shademodel(NNato *x, long type);
void nnato_klr(NNato *x, long red, long green, long blue);
void nnato_normalz(NNato *x, long koordx, long koordy, long koordz);
void nnato_texture(NNato *x, long flag);
void nnato_revertgeo(NNato *x);
void nnato_revert(NNato *x);

void nnato_vectinit(NNato *x);

void nnato_grid(NNato *x, long grid);
void nnato_list(NNato *x, Symbol *s, short argc, Atom *argv);
void nnato_float(NNato *x,double flag);				
void nnato_st(NNato *x, float st);
void nnato_doubl(NNato *x, long flag);
void nnato_ignitv(NNato *x, int flaag, float flag);
void nnato_shifth(NNato *x, int amount);
void nnato_shifthh(NNato *x, int amount);
void nnato_rate(NNato *x, float n);
void nnato_border(NNato *x, long flag);

void nnato_linew(NNato *x, float n, int l);
//void nnato_hv(NNato *x, float m, float o);
void nnato_tunSize (NNato *x, long flag);
void nnato_rott(NNato *x, float m, float o, float p );

void nnato_hv_set(NNato *x, float m, float o); // only set xy
void nnato_rot_set(NNato *x, float m, float o, float p);//only set r.xyz
void nnato_hv_only(NNato *x, float m, float o);
void nnato_hv_do(NNato *x, float m, float o); //do with xy coords
void nnato_hv_rot_do(NNato *x, float m, float o, float rx, float ry, float rz);//do with rot only
void nnato_hv_fi(NNato *x); //only fifo
void nnato_hv_rot(NNato *x, float m, float o, float rx, float ry, float rz); //synked all inputs
void nnato_tunReport (NNato *x) ;

void nnato_glfun(n2glatom glatom);
void nnato_glfun2(n2glatom glatom);		//
void nnato_glfun3(n2glatom glatom);
void nnato_glfun4(n2glatom glatom);
void nnato_glregister(NNato *x, void *klientz);
void    *nnato_class;



main()
{
	setup(&nnato_class, nnato_new, (method)nnato_free, (short)sizeof(NNato), 0L, 0L, 0);

 	addmess((method)nnato_assist,	                  "assist",          	A_CANT,0);
 	addmess((method)nnato_info,	                      "info",		        A_CANT,0);

    n2objaddglcmd();
    n2addstatecmd((method)nnato_int,(method)nnato_bang,
                  (method)nnato_on,-1,-1,-1,-1,(method)nnato_variant,0);

    addmess((method)nnato_klr,                        "color",              A_DEFLONG,A_DEFLONG,A_DEFLONG,0);
    addmess((method)nnato_texture,                    "texture",            A_DEFLONG,0);
    addmess((method)nnato_revert,                     "revert",             0);

    addmess((method)nnato_grid,"grid",A_DEFLONG,A_DEFLONG,0);
	addmess((method)nnato_list,"list",A_GIMME, 0);
	addfloat((method)nnato_float);
    addmess((method)nnato_st,"stride",A_DEFFLOAT, 0);
    addmess((method)nnato_shademodel,"model",A_DEFLONG,0);
    addmess((method)nnato_type,"type",A_DEFLONG,0);
    addmess((method)nnato_normalz,"normal",A_DEFLONG,A_DEFLONG,A_DEFLONG,0);
    addmess((method)nnato_shifth,"shift.left",0);
    addmess((method)nnato_shifthh,"shift.right",0);
    addmess((method)nnato_shifthh,"rate",A_DEFFLOAT,0);
    addmess((method)nnato_border,"border",A_DEFLONG,0);

    addmess((method)nnato_drawFaceNorms,"face_norms",A_DEFLONG,0);
    addmess((method)nnato_calcFaceNorms,"calc_face_norms",A_DEFLONG,0);
    addmess((method)nnato_antialias,"antialias",A_DEFLONG,0);

    addmess((method)nnato_linew,"linew",A_DEFFLOAT,A_DEFLONG, 0);
    addmess((method)nnato_hv_do,"hv",A_DEFFLOAT,A_DEFFLOAT, 0);
    addmess((method)nnato_tunSize,"t.size",A_DEFLONG,0);
    addmess((method)nnato_rot_set,"rot",A_DEFFLOAT,A_DEFFLOAT, A_DEFFLOAT, 0);
    addmess((method)nnato_hv_fi,"fi",0);
//    addmess((method)nnato_hv_rot_do,"hvr",A_DEFFLOAT,A_DEFFLOAT, A_DEFFLOAT,A_DEFFLOAT, A_DEFFLOAT, 0);
    addmess((method)nnato_hv_rot,"hvr",A_DEFFLOAT,A_DEFFLOAT, A_DEFFLOAT,A_DEFFLOAT, A_DEFFLOAT, 0);
    addmess((method)nnato_hv_set,"hv.set",A_DEFFLOAT,A_DEFFLOAT, 0);
    addmess((method)nnato_rot_set,"rot.set",A_DEFFLOAT,A_DEFFLOAT,A_DEFFLOAT, 0);
    addmess((method)nnato_tunReport,"report",0);

    n2reklama();
    post("Н		Eastern Bunny",0);
    n2addfklass("242.gltunnel");	
}





void nnato_assist(NNato *x, void *b, long msg, long nr, char *s)
{
/*	if (msg == 1)      // !nlet
	   strcpy( s, m9ndfukcpropaganda00);
       {
	   if (msg == 2)   // outlet
	      if (nr == 0)
	         strcpy( s, n2gltypestr);  // default `gl data type` outlet de[a]ss!zt--
	   }
*/
}


void nnato_info(NNato *x, void *p, void *b)
{ 
 //    n2info();
}


void *nnato_new()
{
    NNato      *x;
	short      err, i,j;

	x = (NNato *)newobject(nnato_class);
    n2addoutlet(x,&x->glout);    

    if (err = n2objinit(x))
       { post("242.glplain :  n2initobjekt err = %ld",err); return;} 

	x->ignt=0;
    nnato_revert(x);
    post("revert bypassed",0);

//    nnato_vectinit(x);

	
    for(i=0;i < x->grid; i++)
        for(j=0;j < x->grid; j++){
			posit[i][j] = 0.0f; 
	}
		
	post ("zeroed vector i count %ld j count %ld", i, j,0);

    for(i=0;i < MAXLEN; i++) {
    	x->tunnel[i].x=0.0f ;
    	x->tunnel[i].y=0.0f ;   
    	x->tunnel[i].rotx=0.0f ;
    	x->tunnel[i].roty=0.0f ;
    	x->tunnel[i].rotz=0.0f ;
    	}

	post ("zeroed tunnel i count %ld ", i,0);

/*
    for(i=0; i < MAXGRID; i++)
    	x->inputlist[i]=0.0f;
    post("inputlist zeroed  and i is %ld",i,0);
*/


    n2objsetglregister(x,(method)nnato_glregister);   // zpecify gl regizter routine
    n2objsetglfun(x,(method)nnato_glfun);             // zpecify gl drau routine
    post("registered and set fun",0);

		
	x->on = true;
    post("x->on = true",0);
    
    
	return (x);
   
ikk:
	nnato_free(x);
}



void nnato_free(NNato *x) { n2objfree(x); }



void nnato_on(NNato *x, long flag)
{    
    x->on = flag;
}  


void nnato_int(NNato *x, long n)    
{								    
   if (!n) x->on = false;
   else x->on = true;
}


void nnato_bang(NNato *x)
{
   n2gldraw(x, n2objtype);
}


void nnato_variant(NNato *x, short variant)
{
   if (!variant) n2objsetglfun(x,(method)nnato_glfun);
   else if (variant==1) n2objsetglfun(x,(method)nnato_glfun2);
   else if (variant==2) n2objsetglfun(x,(method)nnato_glfun3);
   else if (variant==3) n2objsetglfun(x,(method)nnato_glfun4);
}

void nnato_st(NNato *x, float st)
{
 	x->st   = st;
 }


void nnato_type(NNato *x, short type)
{
   if (type >= 0 && type <= 9) x->type = type;
}



void nnato_klr(NNato *x, long red, long green, long blue)
{
   x->red   = (float)red   * 0.01;
   x->green = (float)green * 0.01;
   x->blue  = (float)blue  * 0.01;      
}  



void nnato_normalz(NNato *x, long koordx, long koordy, long koordz)
{
   x->normalx  = (float)koordx * 0.01;
   x->normaly  = (float)koordy * 0.01;
   x->normalz  = (float)koordz * 0.01;      
}  




void nnato_shademodel(NNato *x, long type)
{
   if (type == 0) x->shademodel = GLU_SMOOTH;
   else if (type == 1) x->shademodel = GLU_FLAT;
   else if (type == 2) x->shademodel = GLU_NONE;
}




void nnato_doubl(NNato *x, long flag)
{
    x->doubl = flag;
}

void nnato_texture(NNato *x, long flag)
{
    x->texture = flag;
}

void nnato_border(NNato *x, long flag)
{    
    x->border = flag;
}  

void nnato_revert(NNato *x)
{	

    x->normalx = x->normaly = 0.0;
    x->normalz = 1.0;
     x->tunSize = 10;   
//    nnato_grid(x,64);
    x->grid=64;
//    x->grid=128;
  //  x->grid=128;

	x->ignt=0;
    x->step=0;
    x->st= 1.0;
    x->texture = true;
    x->rate=0.;
        x->border=0;
    nnato_klr(x,50,50,50);
    
    x->calcFaceNorms = 0;
    x->drawFaceNorms = 0;
    x->antialias = 0;
}

void nnato_grid(NNato *x, long grid)
{
/*	if((grid<MAXGRID&&grid>0))//&&	\

{
//	(grid<MAXGRID&&grid>0)){
    x->grid = grid;
//    x->grid = grid;
    x->step = 0; 
    nnato_vectinit(x);//lets begin again
//    } else {
//    x->grid = 64;
//   x->grid = 64;    
    }
*/
	if((grid<MAXGRID&&grid>0))
		x->grid = grid;
	getTexCoords(x);
}

void nnato_vectinit(NNato *x)
{
	short i,j;
	
    for(i=0;i<x->grid;i++)
        for(j=0;j<x->grid;j++)
		{
			posit[i][j] = 0.0f; 
		}
}

void nnato_rate(NNato *x, float n)
{    
    int cand=0, i, j;
    
    x->rate = n ;//* 0.01;
    
      for(i=1; i<x->grid; i++){
	   for(j=0; j<x->grid; j++)	{
	   	cand = (i+j)%2;
	   	if (!cand) posit[i][j] += (posit[i][j]*x->rate);		//even numbrs
	   	else if (cand==1)
		 posit[i][j] -= (posit[i][j]*x->rate);				//odd numbrs
		}  
	}  
}  



void nnato_ignitv(NNato *x, int flaag, float flag)
{
    register short i, j;
    
    posit[0][flaag]=flag;
     if (flaag==x->grid-1)	{
      for(i=1; i<x->grid; i++){
	   for(j=0; j<x->grid; j++)	{
		 posit[i][j] = posit[i-1][j];	//_copy	next			
//		 posit[i][j] = 0.01f;	//just zero the vector out			
	  		}	
	   	   }
	
		x->ignt=true;
		post("x->ignt=%ld", x->ignt,0);
  
	 	}
}

void nnato_list(NNato *x, Symbol *s, short argc, Atom *argv)
{

	register short 	i, j;
	short	indi, grid=x->grid;
	float	poslisratio, incremento, a, b, indice, val;
	
	if (argc > 64) return;

	for (i=0; i < argc; i++) {
		if (argv[i].a_type==A_LONG) {
			x->inputlist[i] = (float)argv[i].a_w.w_long * 0.01;//divide por 100 se int
		}
		else if (argv[i].a_type==A_FLOAT) {
			x->inputlist[i] = argv[i].a_w.w_float;
		}
	 }


	if (argc == 64) goto stemall;

	poslisratio = (float)grid / argc;
	
	for(j=0; j<grid; j++){
			indice = ((float)j/poslisratio);// valor inteiro
			indi = (int)(indice);		// valor arredondado
			a = x->inputlist[indi];
			b = x->inputlist[indi+1];
			incremento = (float) ((b-a)/poslisratio)*((indi+1)-indice);
			val = (float)x->inputlist[indi] + incremento;
//			if(x->ignt==true) {
				posit[0][j]=val;	//entra elemento para a posicao 0
//					}
//			else nnato_ignitv(x, j, val);
//			if(x->ignt==0) {
//				nnato_ignitv(x, j, val);
//				}
//			else if (x->ignt==1) {
//				posit[0][j]=val;	//entra elemento para a posicao 0
//			}
		}
		
		
		
// o elemento da posicao 1 passa para a pos 2, ie cpstep+1->c[step+2
// depois o elemnto da pos 1 copia zero
justdoit:		
	for(i=grid-1; i>=0; --i)
	for(j=grid; j>=0; --j){
//		if(!x->border)
		 posit[i+1][j] = posit[i][j];	//_copy	next
//		else
//		if(x->border)
//			if( j==0 ||  i == 0	|| j == grid-1 || i == grid-2)
//				posit[i][j]=0.0f;			
//		if (i==0||j==0||i==grid-1||j==grid-1) posit[i][j]=0.0;
		}	
	   

	return;
stemall:
	for(j=0; j<grid; j++){
	posit[0][j]=x->inputlist[j];
	} 
	goto justdoit;
}

void nnato_float(NNato *x,double flag)
{
	register short 	i, j;
	short grid=x->grid;


	for(j=0; j<grid; j++){
				posit[0][j]=(float)flag;	//entra elemento para a posicao 0
		}


	for(i=grid-1; i>=0; --i)
	for(j=grid; j>=0; --j){
//		if(!x->border)
		 posit[i+1][j] = posit[i][j];	//_copy	next
//		else if (x->border) {
//			if( j==0 ||  i == 0	|| j == grid-1 || i == grid-2) {
//				posit[i+1][j]=0.0f;	
//			  	} 
//			  else posit[i+1][j] = posit[i][j];	
//		}	
//		if (i==0||j==0||i==grid-1||j==grid-1) posit[i][j]=0.0;
	}
}


void nnato_shifth(NNato *x, int amount)
{
	register short i, j;
//	short	a1,b1;
	
//	if (amount){

	for(i=x->grid-1; i>=0; --i)
	for(j=x->grid-1; j>=0; --j){
//		a1=amount+j;
//		b1=a1%j;
//		 posit[i][b1] = posit[i+1][j];	//not 					
//		 posit[i][j+1] = posit[i+1][j];	//shift 1 left			
		 posit[i+1][j+1] = posit[i][j];	//shift 1 left			
	  }	

  // }

}

void nnato_shifthh(NNato *x, int amount)
{
	register short i, j;
	short	a1,b1;
	
//	if (amount){

	for(i=x->grid-1; i>=0; --i)
	for(j=0; j<x->grid-1; j++){
//		a1=amount+j;
//		b1=a1%j;
//		 posit[i][b1] = posit[i+1][j];	//not 					
		 posit[i+1][j] = posit[i][j+1];	//shift 1 left			
	  }	

//   }

}


void nnato_linew(NNato *x, float n, int l)
{
	x->linewidth = n;
	if (l) x->lsmooth = 1;
	if (!l) x->lsmooth = 0;
}

void nnato_hv_set(NNato *x, float m, float o)
{
	x->x = m;
	x->y = o;
}

void nnato_rot_set(NNato *x, float m, float o, float p)
{
	x->rotx = m;
	x->roty = o;
	x->rotz = p;
}

void nnato_hv_only(NNato *x, float m, float o)
{
	//set @ origin
	x->tunnel[0].x = m;
	x->tunnel[0].y = o;
	x->tunnel[0].rotx = x->rotx;
	x->tunnel[0].roty = x->roty;
	x->tunnel[0].rotz = x->rotz;
}

void nnato_hv_do(NNato *x, float m, float o) //set and cycle
{
	register short i;

	//set @ origin
	x->tunnel[0].x = m;
	x->tunnel[0].y = o;
	x->tunnel[0].rotx = x->rotx;
	x->tunnel[0].roty = x->roty;
	x->tunnel[0].rotz = x->rotz;

	//copy @ fifo tunnel struct
	for(i = x->tunSize-1; i>=0; --i){
		x->tunnel[i].x = x->tunnel[i+1].x;
		x->tunnel[i].y = x->tunnel[i+1].y;
		x->tunnel[i].rotx = x->tunnel[i+1].rotx;
		x->tunnel[i].roty = x->tunnel[i+1].roty;
		x->tunnel[i].rotz = x->tunnel[i+1].rotz;
	}

}

void nnato_hv_rot_do(NNato *x, float m, float o, float rx, float ry, float rz)
{
	//set @ origin
	x->tunnel[0].x = m;
	x->tunnel[0].y = o;
	x->tunnel[0].rotx = rx;
	x->tunnel[0].roty = ry;
	x->tunnel[0].rotz = rz;
}

void nnato_hv_fi(NNato *x)
{
	register short i;

	//set @ origin
	x->tunnel[0].x = x->x;
	x->tunnel[0].y = x->y;
	x->tunnel[0].rotx = x->rotx;
	x->tunnel[0].roty = x->roty;
	x->tunnel[0].rotz = x->rotz;

	//copy @ fifo tunnel struct
	for(i = x->tunSize-1; i>=0; --i){
		x->tunnel[i].x = x->tunnel[i+1].x;
		x->tunnel[i].y = x->tunnel[i+1].y;
		x->tunnel[i].rotx = x->tunnel[i+1].rotx;
		x->tunnel[i].roty = x->tunnel[i+1].roty;
		x->tunnel[i].rotz = x->tunnel[i+1].rotz;
	}


}
void nnato_hv_rot(NNato *x, float m, float o, float rx, float ry, float rz)
{
	register short i;

	//set @ origin
	x->tunnel[0].x = m;
	x->tunnel[0].y = o;
	x->tunnel[0].rotx = rx;
	x->tunnel[0].roty = ry;
	x->tunnel[0].rotz = rz;

	//copy @ fifo tunnel struct
	for(i = x->tunSize-1; i>=0; --i){
		x->tunnel[i].x = x->tunnel[i+1].x;
		x->tunnel[i].y = x->tunnel[i+1].y;
		x->tunnel[i].rotx = x->tunnel[i+1].rotx;
		x->tunnel[i].roty = x->tunnel[i+1].roty;
		x->tunnel[i].rotz = x->tunnel[i+1].rotz;
	}

}

void nnato_tunSize (NNato *x, long flag) { x->tunSize = flag ; }

void nnato_tunReport (NNato *x) 
{
	short i;

	post("tunnel report:",0);	
	post("			tunnel size: %ld",x->tunSize, 0);	

	for(i =0; i<= x->tunSize-1; i++){
	post("			tunnel bit: %ld",i, 0);	
	post("			tunnel bit.x   : %f",x->tunnel[i].x,0) ;
	post("			tunnel bit.y   : %f",x->tunnel[i].y,0) ;
	post("			tunnel bit.rotx: %f",x->tunnel[i].rotx,0) ;
	post("			tunnel bit.roty: %f",x->tunnel[i].roty,0) ;
	post("			tunnel bit.rotz: %f",x->tunnel[i].rotz,0) ;
	}
 
}





void nnato_glfun(n2glatom glatom) // draw wireframe
{
    NNato *x = (NNato *)n2getglatomobj(glatom);

	short	i,j, tsize = x->tunSize;
	float   st = x->st; 
   
    if (!x->on) return;
    

//    glTranslatef(0., 0., -tsize / 2.0 + .5); //center it
    glColor3f(x->red, x->green, x->blue);	//color it

 	if(x->lsmooth) glEnable(GL_LINE_SMOOTH);
	if(!x->lsmooth) glDisable(GL_LINE_SMOOTH);
	glLineWidth(x->linewidth);

 	
    for(i=0;i < tsize; i++) {
	 	glBegin(x->type);	 	        
 		glNormal3f(x->normalx,x->normaly,x->normalz);
 
        glRotatef(x->tunnel[i].rotx, 1, 0, 0); 	//pitch
        glRotatef(x->tunnel[i].rotz, 0, 0, 1);        //yaw
        glRotatef(x->tunnel[i].roty, 0, 1, 0);			//roll
 	
	 	if (x->texture)
	 	   {
		        glTexCoord2f(0.0f, 0.0f);
	                glVertex3f(-x->tunnel[i].x, -x->tunnel[i].y, st*i);
		        glTexCoord2f(1.0f, 0.0f);
	               glVertex3f( x->tunnel[i].x, -x->tunnel[i].y, st*i);
		        glTexCoord2f(1.0f, 1.0f);
	                glVertex3f( x->tunnel[i].x,  x->tunnel[i].y, st*i);
		        glTexCoord2f(0.0f, 1.0f);
	                glVertex3f(-x->tunnel[i].x,  x->tunnel[i].y, st*i);
	 	   }
	 	else
	 	   {
                glVertex3f(-x->tunnel[i].x, -x->tunnel[i].y, st*i);
                glVertex3f( x->tunnel[i].x, -x->tunnel[i].y, st*i);
                glVertex3f( x->tunnel[i].x,  x->tunnel[i].y, st*i);
                glVertex3f(-x->tunnel[i].x,  x->tunnel[i].y, st*i);
	       }
		glEnd();
    }
  
}    
 

void nnato_glfun2(n2glatom glatom)	//draew textured
{
    NNato *x = (NNato *)n2getglatomobj(glatom);

	short	i,j, grid=x->grid;
	float   st=x->st; 
   
    if (!x->on) return;
    
    if (x->antialias)
    {
        glEnable(GL_BLEND);
        glBlendFunc(GL_SRC_ALPHA, GL_ONE_MINUS_SRC_ALPHA);
        glEnable(GL_LINE_SMOOTH);
        glLineWidth(1.5);
    }
    else
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }

    glTranslatef(-grid / 2.0 + .5, -grid / 2.0 + .5, 0); //center it
    glColor3f(x->red, x->green, x->blue);	//color it

    if (x->calcFaceNorms) {
    getFaceNorms(x);
    getVertNorms(x);
	}

//    	{ drawTextured(x); }

    glEnable(GL_TEXTURE_2D);
    for (i = 0; i < grid - 1; ++i)
    {
        glBegin(GL_TRIANGLE_STRIP);
        for (j = 0; j < grid; ++j)
        {
            glNormal3fv( vertNorms[i][j] );
            glTexCoord2fv( texCoords[i][j] );
            glVertex3f( i, j, posit[i][j] );
            glNormal3fv( vertNorms[i+1][j] );
            glTexCoord2fv( texCoords[i+1][j] );
            glVertex3f( i+1, j, posit[i+1][j] );
        }
        glEnd();
    }
    glDisable(GL_TEXTURE_2D);


    if (x->drawFaceNorms)    
    {
        getFaceNormSegs(x);
        drawFaceNormals(x);
    }


/*    if (x->antialias)
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }
*/

}
  
    
void nnato_glfun3(n2glatom glatom) // { drawSmoothShaded(x); }
{
    NNato *x = (NNato *)n2getglatomobj(glatom);

	short	i,j, grid=x->grid;
	float   st=x->st; 
   
    if (!x->on) return;
    
    if (x->antialias)
    {
        glEnable(GL_BLEND);
        glBlendFunc(GL_SRC_ALPHA, GL_ONE_MINUS_SRC_ALPHA);
        glEnable(GL_LINE_SMOOTH);
        glLineWidth(1.5);
    }
    else
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }

    glTranslatef(-grid / 2.0 + .5, -grid / 2.0 + .5, 0); //center it
//    glColor3f(x->red, x->green, x->blue);	//color it

    if (x->calcFaceNorms) {
    getFaceNorms(x);
    getVertNorms(x);
	}

//    glEnable(GL_POLYGON_OFFSET_FILL);
    glColor3f(x->red, x->green, x->blue);	//color it
    for (i = 0; i < x->grid - 1; ++i)
    {
        glBegin(GL_TRIANGLE_STRIP);
        for (j = 0; j < x->grid; ++j)
        {
            glNormal3fv( vertNorms[i][j] );
            glVertex3f( i, j, posit[i][j] );
            glNormal3fv( vertNorms[i+1][j] );
            glVertex3f( i+1, j, posit[i+1][j] );
        }
        glEnd();
    }

    if (x->drawFaceNorms)    
    {
        getFaceNormSegs(x);
        drawFaceNormals(x);
    }
//    glDisable(GL_POLYGON_OFFSET_FILL);
/*    if (x->antialias)
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }
*/
 
}    
 

void nnato_glfun4(n2glatom glatom) // //    drawFlatShaded(x); }
{
    NNato *x = (NNato *)n2getglatomobj(glatom);

	short	i,j, grid=x->grid;
	float   st=x->st, rate=x->rate; 
   
    if (!x->on) return;
    
    if (x->antialias)
    {
        glEnable(GL_BLEND);
        glBlendFunc(GL_SRC_ALPHA, GL_ONE_MINUS_SRC_ALPHA);
        glEnable(GL_LINE_SMOOTH);
        glLineWidth(1.5);
    }
    else
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }

    glTranslatef(-grid / 2.0 + .5, -grid / 2.0 + .5, 0); //center it
    glColor3f(x->red, x->green, x->blue);	//color it

    if (x->calcFaceNorms) {
    getFaceNorms(x);
    getVertNorms(x);
	}

    glEnable(GL_POLYGON_OFFSET_FILL);
 
     for (i = 0; i < x->grid - 1; ++i)
    {
        glBegin(GL_TRIANGLE_STRIP);
        glVertex3f( (float) i, (float) 0, (float) posit[i][0]);
        glVertex3f( (float) i+1, (float) 0, (float) posit[i+1][0]);
        for (j = 1; j < x->grid; ++j)
        {
            glNormal3fv( faceNorms[0][i][j-1] );
            glVertex3f( (float) i, (float) j, (float) posit[i][j]);
              glNormal3fv( faceNorms[1][i][j-1] );
            glVertex3f( (float) i+1, (float) j, (float) posit[i+1][j]);
        }
        glEnd();
    }
    glDisable(GL_POLYGON_OFFSET_FILL);

/*    if (x->antialias)
    {
        glDisable(GL_BLEND);
        glDisable(GL_LINE_SMOOTH);
        glLineWidth(1.0);
    }
*/

}


void nnato_glregister(NNato *x, void *klientz)
{
    n2glregisterx(x,n2objtype,x->glout,klientz);  // bkom 01 klient ov gl alimentari data
}			



/* face normals - for flat shading */
void getFaceNorms(NNato *x)
{
	int i,j;
    float vec0[3], vec1[3], vec2[3], norm0[3], norm1[3];
    float geom0[3], geom1[3], geom2[3], geom3[3];

    for (i = 0; i < x->grid-1; ++i)
    {
        for (j = 0; j < x->grid-1; ++j)
        {
            /* get vectors from geometry points */
            geom0[0] = i; geom0[1] = j; geom0[2] = posit[i][j];
            geom1[0] = i; geom1[1] = j+1; geom1[2] = posit[i][j+1];
            geom2[0] = i+1; geom2[1] = j; geom2[2] = posit[i+1][j];
            geom3[0] = i+1; geom3[1] = j+1; geom3[2] = posit[i+1][j+1];

            sub( vec0, geom1, geom0 );
            sub( vec1, geom1, geom2 );
            sub( vec2, geom1, geom3 );

            /* get triangle face normals from vectors & normalize them */
            cross( norm0, vec0, vec1 );
            norm( norm0 );

            cross( norm1, vec1, vec2 ); 
            norm( norm1 );

            copy( faceNorms[0][i][j], norm0 );
            copy( faceNorms[1][i][j], norm1 );
        }
    }
}


/* vertex normals - average of face normals for smooth shading */
void getVertNorms(NNato *x)
{
	int i,j;
    float avg[3];
    for (i = 0; i < x->grid; ++i)
    {
        for (j = 0; j < x->grid; ++j)
        {
            /* For each vertex, average normals from all faces sharing */
            /* vertex.  Check each quadrant in turn */
            set(avg, 0.0, 0.0, 0.0);

            /* Right & above */
            if (j < x->grid-1 && i < x->grid-1)
            {
                add( avg, avg, faceNorms[0][i][j] );
            }
            /* Right & below */
            if (j < x->grid-1 && i > 0)
            {
                add( avg, avg, faceNorms[0][i-1][j] );
                add( avg, avg, faceNorms[1][i-1][j] );
            }
            /* Left & above */
            if (j > 0 && i < x->grid-1)
            {
                add( avg, avg, faceNorms[0][i][j-1] );
                add( avg, avg, faceNorms[1][i][j-1] );
            }
            /* Left & below */
            if (j > 0 && i > 0)
            {
                add( avg, avg, faceNorms[1][i-1][j-1] );
            }

            /* Normalize */
            norm( avg );
            copy( vertNorms[i][j], avg );
        }
    }
}


void getFaceNormSegs(NNato *x)
{
	int i,j;
    float center0[3], center1[3], normSeg0[3], normSeg1[3];
    float geom0[3], geom1[3], geom2[3], geom3[3];
 
    for (i = 0; i < x->grid - 1; ++i)
    {
        for (j = 0; j < x->grid - 1; ++j)
        {
            geom0[0] = i; geom0[1] = j; geom0[2] = posit[i][j];
            geom1[0] = i; geom1[1] = j+1; geom1[2] = posit[i][j+1];
            geom2[0] = i+1; geom2[1] = j; geom2[2] = posit[i+1][j];
            geom3[0] = i+1; geom3[1] = j+1; geom3[2] = posit[i+1][j+1];

            /* find center of triangle face by averaging three vertices */
            add( center0, geom2, geom0 );
            add( center0, center0, geom1 );
            scalDiv( center0, 3.0 );

            add( center1, geom2, geom1 );
            add( center1, center1, geom3 );
            scalDiv( center1, 3.0 );

            /* translate normal to center of triangle face to get normal segment */
            add( normSeg0, center0, faceNorms[0][i][j] );
            add( normSeg1, center1, faceNorms[1][i][j] );

            copy( faceNormSegs[0][0][i][j], center0 );
            copy( faceNormSegs[1][0][i][j], center1 );

            copy( faceNormSegs[0][1][i][j], normSeg0 );
            copy( faceNormSegs[1][1][i][j], normSeg1 );
        }
    }
}

void getTexCoords(NNato *x)
{
	int i,j;

    for (i = 0; i < x->grid; ++i)
    {
        for (j = 0; j < x->grid; ++j)
        {
            texCoords[i][j][0] = (float)j/(float)(x->grid-1);
            texCoords[i][j][1] = (float)i/(float)(x->grid-1);
        }
    }
}

void drawFaceNormals(NNato *x)
{
    int i,j;
    glColor3f(1.0,1.0,1.0);
    for (i = 0; i < x->grid - 1; ++i)
    {
        for (j = 0; j < x->grid - 1; ++j)
        {
            glBegin(GL_LINES);
            glVertex3fv(faceNormSegs[0][0][i][j]);
            glVertex3fv(faceNormSegs[0][1][i][j]);
            glEnd();

            glBegin(GL_LINES);
            glVertex3fv(faceNormSegs[1][0][i][j]);
            glVertex3fv(faceNormSegs[1][1][i][j]);
            glEnd();
        }
    }
}

void nnato_drawFaceNorms(NNato *x, long flag)
{    
    x->drawFaceNorms = flag;
}  

void nnato_calcFaceNorms(NNato *x, long flag)
{    
    x->calcFaceNorms = flag;
}  

void nnato_antialias(NNato *x, long flag)
{    
    x->antialias = flag;
}  



// math
void copy(float vec0[3], float vec1[3])
{
    vec0[0] = vec1[0];
    vec0[1] = vec1[1];
    vec0[2] = vec1[2];
}

void sub(float vec0[3], float vec1[3], float vec2[3])
{
    vec0[0] = vec1[0] - vec2[0];
    vec0[1] = vec1[1] - vec2[1];
    vec0[2] = vec1[2] - vec2[2];
}

void add(float vec0[3], float vec1[3], float vec2[3])
{
    vec0[0] = vec1[0] + vec2[0];
    vec0[1] = vec1[1] + vec2[1];
    vec0[2] = vec1[2] + vec2[2];
}

void scalDiv(float vec[3], float c)
{
    vec[0] /= c; vec[1] /= c; vec[2] /= c;
}

void cross(float vec0[3], float vec1[3], float vec2[3])
{
    vec0[0] = vec1[1] * vec2[2] - vec1[2] * vec2[1];
    vec0[1] = vec1[2] * vec2[0] - vec1[0] * vec2[2];
    vec0[2] = vec1[0] * vec2[1] - vec1[1] * vec2[0];
}

void norm(float vec[3])
{
    float c = sqrt(vec[0] * vec[0] + vec[1] * vec[1] + vec[2] * vec[2]);
    scalDiv(vec, c); 
}

void set(float vec[3], float x, float y, float z)
{
    vec[0] = x;
    vec[1] = y;
    vec[2] = z;
}


/*----------------------------------------------------------
	EOF
----------------------------------------------------------*/




